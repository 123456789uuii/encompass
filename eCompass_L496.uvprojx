# Keil uVision project eCompass_L496.uvprojx, settings and files
target eCompass_L496 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L496RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2003FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: eCompass_L496 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L496xx
  c misc: --wchar32 --diag_suppress=68,111,188,223,546
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/XL;../Drivers/BSP/Components/charpic;../Drivers/BSP/Components/motion/Common/Inc;../Drivers/BSP/Components/motion/iis2dlpc;../Drivers/BSP/Components/motion/iis2mdc;../Drivers/BSP/Components/motion/ism330dhcx;../Drivers/BSP/Components/ms5837;../Drivers/BSP/Components/bdgps;../Drivers/BSP/Components/encoder;../Middlewares/ST/STM32_MotionEC_Library/Inc;../Middlewares/ST/STM32_MotionMC_Library/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User/Core
    ../Core/Src/: app.c spi_Driver.c W25Qxx_Driver.c Common_Driver.c main.c gpio.c freertos.c adc.c crc.c i2c.c quadspi.c rtc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Drivers/BSP/XL
    ../Drivers/BSP/Components/XL/: chsc6x_comp.c chsc6x_main.c chsc6x_platform.c ledono.c ledono.h
  group Drivers/BSP/Components/motion/Common/Src
    ../Drivers/BSP/Components/motion/Common/Src/: app_mems.c com.c demo_serial.c iks02a1_mems_control.c iks02a1_mems_control_ex.c iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c motion_ec_manager.c motion_mc_manager.c nucleo.c nucleo_bus.c serial_protocol.c
  group Drivers/BSP/Components/motion/iis2mdc
    ../Drivers/BSP/Components/motion/iis2mdc/: iis2mdc.c iis2mdc_reg.c
  group Drivers/BSP/Components/motion/ism330dhcx
    ../Drivers/BSP/Components/motion/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
  group Drivers/BSP/Components/motion/iis2dlpc
    ../Drivers/BSP/Components/motion/iis2dlpc/: iis2dlpc.c iis2dlpc_reg.c
  group Middlewares/STM32_MotionEC_Library
    ../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM3_wc32_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM3_wc32_ot.a
  group Drivers/BSP/Components/ms5837
    ../Drivers/BSP/Components/ms5837/: ms5837function.c
  group Drivers/BSP/Components/bdgps
    ../Drivers/BSP/Components/bdgps/: gps.c
  group Drivers/BSP/Components/encoder
    ../Drivers/BSP/Components/encoder/: encoder.c
software components: CMSIS:CORE 4.3.0
